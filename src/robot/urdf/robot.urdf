Commit message: try publish again

File: src/robot/urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot, 7 links, 6 joints
Links:
- link base_Link: geometry collision sphere radius=0.005; visual mesh filename=file:///home/yixi/ROS/zjunlict/src/robot/meshes/base_Link.S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
